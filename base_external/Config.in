## base_external/package/hello-world/Config.in
```kconfig
config BR2_PACKAGE_HELLO_WORLD
	bool "hello-world"
	help
	  Hello world example for to show Buildroot external trees and package builds.
```
